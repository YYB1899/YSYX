## nemu/configs/riscv32_defconfig
```kconfig
# CONFIG_TARGET_AM is not set
# CONFIG_TRACE is not set
CONFIG_MBASE=0x0
CONFIG_MSIZE=0x81000000
CONFIG_PMEM_MALLOC=y
CONFIG_DEVICE=y 
```
